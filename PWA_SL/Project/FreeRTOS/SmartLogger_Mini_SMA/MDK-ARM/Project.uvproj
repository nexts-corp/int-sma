# Keil uVision project Project.uvproj, settings and files
target Discover-More (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=2 wLevel=2
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c include: ..\;..\User\inc;..\User\src;..\INTELENICS_Driver\inc;..\INTELENICS_Driver\src;..\INTELENICS_Library\inc;..\INTELENICS_Library\src;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Utilities\FatFs_vR0.08a;..\..\..\..\Utilities\STM32F4-Discovery;..\..\..\..\Utilities\FreeRTOSv8.0.1\include;..\..\..\..\Utilities\FreeRTOSv8.0.1\portable\RVDS\ARM_CM4F;..\..\..\..\Project\FreeRTOS\SmartLogger\MDK-ARM;..\..\..\..\Project\FreeRTOS\SmartLogger\MDK-ARM\task;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Libraries\freemodbus\Master\port;..\..\..\..\Libraries\freemodbus\Master\modbus;..\..\..\..\Libraries\freemodbus\Master\modbus\functions;..\..\..\..\Libraries\freemodbus\Master\modbus\ascii;..\..\..\..\Libraries\freemodbus\Master\modbus\rtu;..\..\..\..\Libraries\freemodbus\Master\modbus\include;..\..\..\..\Libraries\freemodbus\Slave\port;..\..\..\..\Libraries\freemodbus\Slave\modbus;..\..\..\..\Libraries\freemodbus\Slave\modbus\functions;..\..\..\..\Libraries\freemodbus\Slave\modbus\ascii;..\..\..\..\Libraries\freemodbus\Slave\modbus\rtu;..\..\..\..\Libraries\freemodbus\Slave\modbus\include;..\..\..\..\Libraries\freemodbus;..\Other_Libraries\src;..\Other_Libraries\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/src/: main.c system_stm32f4xx.c stm32f4xx_it.c tester.c
  group Task
    ../User/src/: Manager_Task.c gsm_task.c Sensors_Task.c Log_Task.c Modbus_Task.c SD_Task.c Data_Task.c
  group STM32F4-Discovery
    ../../../../Utilities/STM32F4-Discovery/: stm32f4_discovery_lcd.c stm32f4_discovery.c stm32f4_discovery_sdio_sd.c
  group STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_usart.c misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_iwdg.c stm32f4xx_i2c.c
  group INTELENICS_Driver
    ../INTELENICS_Driver/src/: stm32f4_SDCard.c
  group INTELENICS_Library
    ../INTELENICS_Library/src/: INT_STM32F4_Timer.c INT_STM32F4_rtc.c INT_STM32F4_adc.c INT_STM32F4_ProtocolParser.c INT_STM32F4_ProtocolComm.c INT_STM32F4_420RClick.c INT_STM32F4_PacketQueue.c INT_STM32F4_ConfigSD.c INT_STM32F4_DataQueue.c INT_STM32F4_log.c INT_STM32F4_debug.c INT_STM32F4_ProtocolHandle.c INT_STM32F4_Usart.c INT_STM32F4_watchdog.c INT_STM32F4_GSM.c INT_STM32F4_aes128.c INT_STM32F4_i2c.c INT_STM32F4_SC16IS750.c INT_STM32F4_FlowMB.c INT_STM32F4_ValveMB.c INT_STM32F4_OneWire.c INT_STM32F4_csvfile.c INT_STM32F4_MCP4725.c INT_STM32F4_24LC1025.c INT_STM32F4_Record.c
  group FreeRTOS
    ../../../../Utilities/FreeRTOSv8.0.1/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
    ../../../../Utilities/FreeRTOSv8.0.1/portable/MemMang/: heap_2.c
    ../../../../Utilities/FreeRTOSv8.0.1/portable/RVDS/ARM_CM4F/: port.c
  group MDK-ARM
    ./: startup_stm32f4xx.s
  group FatFs
    ../../../../Utilities/FatFs_vR0.08a/: diskio.c ff.c
  group Readme
    ../: readme.txt
  group MB_Master
    ../../../../Libraries/freemodbus/Master/modbus/: mb.c
    ../../../../Libraries/freemodbus/Master/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../../../../Libraries/freemodbus/Master/modbus/rtu/: mbcrc.c mbrtu.c
    ../../../../Libraries/freemodbus/Master/port/: portevent.c portserial.c porttimer.c
  group MB_Slave
    ../../../../Libraries/freemodbus/Slave/modbus/: mbSlave.c
    ../../../../Libraries/freemodbus/Slave/modbus/functions/: mbSlavefunccoils.c mbSlavefuncdiag.c mbSlavefuncdisc.c mbSlavefuncholding.c mbSlavefuncinput.c mbSlavefuncother.c mbSlaveutils.c
    ../../../../Libraries/freemodbus/Slave/modbus/rtu/: mbSlavecrc.c mbSlavertu.c
    ../../../../Libraries/freemodbus/Slave/port/: porteventSlave.c portserialSlave.c porttimerSlave.c
  group Other_Library
    ../Other_Libraries/src/: tm_stm32f4_adc.c tm_stm32f4_i2c.c tm_stm32f4_timer_properties.c tm_stm32f4_gpio.c tm_stm32f4_delay.c tm_stm32f4_ds1307.c tm_stm32f4_bkpsram.c
